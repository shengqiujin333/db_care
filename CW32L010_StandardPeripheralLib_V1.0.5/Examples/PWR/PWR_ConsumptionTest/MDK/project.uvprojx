# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: adc_sgl_sw +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c
  group Driver
    ../../../../Libraries/src/: cw32l010_adc.c cw32l010_sysctrl.c cw32l010_systick.c cw32l010_gpio.c cw32l010_lptim.c cw32l010_rtc.c cw32l010_iwdt.c cw32l010_uart.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
