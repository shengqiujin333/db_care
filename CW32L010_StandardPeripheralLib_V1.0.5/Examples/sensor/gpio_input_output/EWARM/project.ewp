# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32L010x8 WHXY CW32L010x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Utilities; ..\UM2005C; ..\COMMON
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CW32L010 CW32L010
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\UM2005C; ..\COMMON
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\CW\cw32l010.icf
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32l010_adc.c cw32l010_digitalsign.c cw32l010_flash.c cw32l010_gpio.c cw32l010_lptim.c cw32l010_rtc.c cw32l010_sysctrl.c cw32l010_uart.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: encrytogate.c debug_trace.c fw_core.c gxht40.c interrupts_cw32l010.c light.c main.c measure.c sf_i2c.c
  group UM2005C
    ../UM2005C/: app_gtimer.c app_um2005C.c radio.c um2005C.c um2005C_hal.c
  group COMMON
    ../COMMON/: convert.c delay.c
