# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\UM2005C;..\COMMON
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c sf_i2c.c measure.c encrytogate.c fw_core.c gxht40.c light.c
  group Driver
    ../../../../Libraries/src/: cw32l010_sysctrl.c cw32l010_gpio.c cw32l010_flash.c cw32l010_rtc.c cw32l010_uart.c cw32l010_lptim.c cw32l010_adc.c cw32l010_digitalsign.c
  group Doc
    ../: readme.txt
  group UM2005C
    ../UM2005C/: radio.c um2005C.c um2005C_hal.c app_gtimer.c app_um2005C.c
  group COMMON
    ../COMMON/: convert.c delay.c
software components: CMSIS:CORE 5.3.0
