# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\UM2005C;..\COMMON;..\user1;..\output\modules\2.1_i2c_driver;..\output\modules\2.2_aht10_driver;..\output\modules\2.3_uart_console;..\output\modules\2.4_rf_twi_driver;..\output\modules\2.5_power_manager;..\output\modules\2.6_packet_builder;..\output\modules\2.7_sensor_mgr;..\output\modules\2.8_schedule;..\output\design
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../output/modules/2.1_i2c_driver/: i2c_driver.c
    ../output/modules/2.2_aht10_driver/: aht10_driver.c
    ../output/modules/2.3_uart_console/: uart_console.c
    ../output/modules/2.4_rf_twi_driver/: rf_twi_driver.c
    ../output/modules/2.5_power_manager/: power_manager.c
    ../output/modules/2.6_packet_builder/: packet_builder.c
    ../output/modules/2.7_sensor_mgr/: sensor_mgr.c
    ../output/modules/2.8_schedule/: schedule.c
  group Driver
    ../../../../Libraries/src/: cw32l010_sysctrl.c cw32l010_gpio.c cw32l010_flash.c cw32l010_rtc.c cw32l010_uart.c cw32l010_lptim.c cw32l010_digitalsign.c cw32l010_adc.c cw32l010_atim.c cw32l010_btim.c cw32l010_crc.c cw32l010_debug.c cw32l010_gtim.c cw32l010_i2c.c cw32l010_iwdt.c cw32l010_lvd.c cw32l010_pwr.c cw32l010_ram.c cw32l010_spi.c cw32l010_systick.c cw32l010_vc.c i2c_eeprom.c
  group Doc
    ../: readme.txt
  group COMMON
    ../COMMON/: convert.c delay.c
software components: CMSIS:CORE 5.3.0
